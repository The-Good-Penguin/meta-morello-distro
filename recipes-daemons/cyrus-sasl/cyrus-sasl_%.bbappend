
GROUPADD_PARAM:${PN}-bin = " -r mail "
# GROUPADD_PARAM:${PN}-bin = " -r cyrus-sasl "
# USERADD_PARAM:${PN}-bin = "--system --home=/var/spool/mail -g cyrus-sasl cyrus"